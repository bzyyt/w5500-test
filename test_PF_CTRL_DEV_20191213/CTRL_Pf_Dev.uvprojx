# Keil uVision project CTRL_Pf_Dev.uvprojx, settings and files
target STM32F429IIHx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CTRL_Pf_Dev
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: .\Code\Driver\Helper;.\Code\Driver\System;.\Code\Driver\Official\STM32F4xx_StdPeriph_Driver_V1.8.0\inc;.\Code\Driver\Helper;.\Code\Driver\Official\CMSIS\Include;.\Code\Driver\Official\W5500;.\Code\User\Algorithm;.\Code\User\Application
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StdDirver
    ./Code/Driver/Official/STM32F4xx_StdPeriph_Driver_V1.8.0/src/: stm32f4xx_dma.c misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fmc.c stm32f4xx_can.c stm32f4xx_adc.c
  group Peripheral
    ./Code/Driver/Helper/: DelayAdapter.c ExtiAdapter.c LedAdapter.c SPIAdapter.c TimAdapter.c UartAdapter.c FmcAdapter.c CanAdapter.c DACAdapter.c ADCAdapter.c UdpAdapter.c GpioAdapter.c
  group Controller
    ./Code/User/Controller/: main.c
  group SysConfig
    ./Code/Driver/System/: system_stm32f4xx.c startup_stm32f429_439xx.s
  group Library
    ./Code/Driver/Official/CMSIS/Lib/: arm_cortexM4lf_math.lib
  group W5500
    ./Code/Driver/Official/W5500/: w5500.c wizchip_conf.c socket.c utility.c w5500_conf.c w5500_control.c
  group Algorithm
    ./Code/User/Algorithm/: ctrlAlgorithm.c
  group Application
    ./Code/User/Application/: tcp_server.c
